## conf/machine/rockchip-rk3308-rockpis.conf
```bitbake
require conf/machine/include/rk3308.inc

KERNEL_DEVICETREE = "rockchip/dummy-rockpis.dtb"

UBOOT_MACHINE = "dummy-rockpis_defconfig"
```
